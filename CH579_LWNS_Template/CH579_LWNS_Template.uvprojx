# Keil uVision project CH579_LWNS_Template.uvprojx, settings and files
target CH57x (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CH579F WCH
  pack: Keil.WCH57x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3E800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CH579_LWNS +hex
  c flags: uC99=1 v6Lang=1 v6LangP=1
  c define: DEBUG
  c include: .\Src\APP\include;.\Drivers\BLE\HAL\include;.\Drivers\BLE\LIB;.\Drivers\BLE\MESH_LIB;.\Core\CMSIS\Include;.\Drivers\StdPeriphDriver\inc;.\Drivers\LWNS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Core
    ./Core/Startup/: startup_ARMCM0.s
  group BLE
    ./Drivers/BLE/HAL/include/: config.h
    ./Drivers/BLE/HAL/: KEY.c LED.c MCU.c RTC.c SLEEP.c
    ./Drivers/BLE/LIB/: CH57xBLE.lib CH57xBLE_LIB.H
    ./Drivers/BLE/MESH_LIB/: MESH_LIB.lib MESH_LIB.h
  group LWNS
    ./Drivers/LWNS/: CH57xLWNS.lib WCH_LWNS_LIB.h
  group StdPeriphDriver
    ./Drivers/StdPeriphDriver/: CH57x_adc.c CH57x_clk.c CH57x_flash.c CH57x_gpio.c CH57x_int.c CH57x_lcd.c CH57x_pwm.c CH57x_pwr.c CH57x_spi0.c CH57x_spi1.c CH57x_sys.c CH57x_timer0.c CH57x_timer1.c CH57x_timer2.c CH57x_timer3.c CH57x_uart0.c CH57x_uart1.c CH57x_uart2.c CH57x_uart3.c CH57x_usbdev.c
  group App
    ./Src/APP/: app_main.c lwns_adapter_blemesh_mac.c lwns_adapter_csma_mac.c lwns_adapter_no_mac.c lwns_sec.c lwns_broadcast_example.c lwns_multicast_example.c lwns_unicast_example.c lwns_ruc_example.c lwns_rucft_example.c lwns_netflood_example.c lwns_multinetflood_example.c lwns_uninetflood_example.c lwns_mesh_example.c
    ./Src/APP/include/: lwns_adapter_blemesh_mac.h lwns_adapter_csma_mac.h lwns_adapter_no_mac.h
